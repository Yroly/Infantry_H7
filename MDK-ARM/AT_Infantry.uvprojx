# Keil uVision project AT_Infantry.uvprojx, settings and files
target AT_Infantry (6160000::V6.16::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: AT_Infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../Infantry_ws;../Infantry_ws/bsp;../Infantry_ws/Lib;../Infantry_ws/devices/DM_Motor;../Infantry_ws/devices/BMI088;../Infantry_ws/Controller;../Infantry_ws/task;../Infantry_ws/Algorithm;../Infantry_ws/Algorithm/EKF;../Infantry_ws/Algorithm/kalman;../Infantry_ws/Algorithm/mahony;../Infantry_ws/Algorithm/PID;../Infantry_ws/Algorithm/VMC;../Infantry_ws/app;../Infantry_ws/Leg;../Infantry_ws/middlewares/io/buzzer;../Infantry_ws/middlewares/io/plotter;../Infantry_ws/middlewares/io/dbus;../Infantry_ws/middlewares/io/watchdog;../Infantry_ws/middlewares/io/bmi088;../Infantry_ws/middlewares/tools/math_tools;../Infantry_ws/middlewares/tools/mahony;../Infantry_ws/middlewares/tools/low_pass_filter;../Infantry_ws/middlewares/tools/pid;../Infantry_ws/middlewares/motor;../Infantry_ws/middlewares/io/sbus
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group task
    ../Infantry_ws/task/: INS_Task.c Chassis_Task.cpp plotter_task.cpp buzzer_task.cpp remote_task.cpp
  group bsp
    ../Infantry_ws/bsp/: bsp_dwt.cpp bsp_can.cpp
  group devices
    ../Infantry_ws/devices/BMI088/: BMI088Middleware.c BMI088driver.c
    ../Infantry_ws/devices/DM_Motor/: dm_motor_drv.cpp
    ../Infantry_ws/middlewares/motor/: drv_dji_motor.cpp
  group Algorithm
    ../Infantry_ws/Algorithm/EKF/: QuaternionEKF.c
    ../Infantry_ws/Algorithm/kalman/: kalman_filter.c algorithm_kalman.cpp
    ../Infantry_ws/Algorithm/PID/: pid.cpp
    ../Infantry_ws/Algorithm/mahony/: mahony_filter.c
  group Leg
    ../Infantry_ws/Leg/: LQR.cpp Mpc.cpp VMC.cpp Legs.cpp Leg.cpp
  group Lib
    ../Infantry_ws/Lib/: user_lib.cpp
  group app
    ../Infantry_ws/app/: app_preference.cpp app_preference.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group middlewares
    ../Infantry_ws/middlewares/io/buzzer/: buzzer.cpp
    ../Infantry_ws/middlewares/io/plotter/: plotter.cpp
    ../Infantry_ws/middlewares/io/watchdog/: watchdog.cpp
    ../Infantry_ws/middlewares/io/bmi088/: bmi088.cpp
    ../Infantry_ws/middlewares/tools/mahony/: mahony.cpp
    ../Infantry_ws/middlewares/tools/math_tools/: math_tools.cpp
    ../Infantry_ws/middlewares/io/sbus/: sbus.cpp
software components: CMSIS:CORE 5.4.0
